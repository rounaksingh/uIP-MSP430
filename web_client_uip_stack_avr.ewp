# IAR project web_client_uip_stack_avr.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    net/: clock-arch.h clock.h enc28j60.c enc28j60.h enc28j60def.h lc-addrlabels.h lc-switch.h lc.h nic.c nic.h psock.c psock.h pt.h timer.c timer.h uip-conf.h uip-empty-packet.c uip-empty-packet.h uip.c uip.h uip_arch.c uip_arch.h uip_arp.c uip_arp.h uipopt.h VERSION.h
    ./: compiler.h delay.c delay.h main.c uNetConfigure.h
    net_app/: dhcpc.c dhcpc.h simple-app.c simple-app.h
